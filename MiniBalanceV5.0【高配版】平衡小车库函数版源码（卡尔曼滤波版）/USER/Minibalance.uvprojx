# Keil uVision project Minibalance.uvprojx, settings and files
target MinibalanceF4 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\MiniBalance\CONTROL;..\MiniBalance\DataScope_DP;..\MiniBalance\filter;..\MiniBalance\show;..\MiniBalance_HARDWARE\ADC;..\MiniBalance_HARDWARE\CAN;..\MiniBalance_HARDWARE\ENCODER;..\MiniBalance_HARDWARE\EXTI;..\MiniBalance_HARDWARE\KEY;..\MiniBalance_HARDWARE\LED;..\MiniBalance_HARDWARE\MOTOR;..\MiniBalance_HARDWARE\NRF24L01;..\MiniBalance_HARDWARE\OLED;..\MiniBalance_HARDWARE\SPI;..\MiniBalance_HARDWARE\STMFLASH;..\MiniBalance_HARDWARE\TIMER;..\MiniBalance_HARDWARE\USARTX;..\MiniBalance_HARDWARE\IIC;..\MiniBalance\MPU6050;..\MiniBalance\DMP;..\MiniBalance_HARDWARE\DataScope;..\MiniBalance_HARDWARE\WS2811;..\MiniBalance_HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../MiniBalance_HARDWARE/ADC/: adc.c
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/EXTI/: exti.c
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/LED/: LED.C
    ../MiniBalance_HARDWARE/MOTOR/: motor.c
    ../MiniBalance_HARDWARE/OLED/: oled.c
    ../MiniBalance_HARDWARE/IIC/: IOI2C.c
    ../MiniBalance_HARDWARE/USARTX/: usartx.c
    ../MiniBalance_HARDWARE/STMFLASH/: stmflash.c
    ../MiniBalance_HARDWARE/SPI/: spi.c
    ../MiniBalance_HARDWARE/NRF24L01/: 24l01.c
    ../MiniBalance_HARDWARE/TIMER/: timer.c
    ../MiniBalance_HARDWARE/CAN/: can.c
    ../MiniBalance_HARDWARE/WS2811/: WS2811.c
    ../MiniBalance_HARDWARE/: deal_datapacket.c
  group MINIBALANCE
    ../MiniBalance/CONTROL/: control.c
    ../MiniBalance/DataScope_DP/: DataScope_DP.C
    ../MiniBalance/filter/: filter.c
    ../MiniBalance/show/: show.c
    ../MiniBalance/MPU6050/: MPU6050.c
    ../MiniBalance/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
